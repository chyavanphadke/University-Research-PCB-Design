# Repository chyavanphadke/University-Research-PCB-Design

File README.md:

# University-Research-PCB-Design
PCB designed for a university project.

Specifications:
4 layered PCB that connects a custom designed chip with the Keysight Chip testing device

<h2>The final Design output</h2>

## KiCad design chipOne_newDesign/chipOne.kicad_pcb

Parts:
CPchip1_C1, CPchip1_C2, CPchip1_C5, CPchip1_C6, CPchip1_C9, CPchip1_C10, CPchip1_C13, CPchip1_C14: 10uF; C_1206_HandSoldering
CPchip1_C3, CPchip1_C4, CPchip1_C7, CPchip1_C8, CPchip1_C11, CPchip1_C12, CPchip1_C15, CPchip1_C16: 100uF; CP_Tantalum_Case-X_EIA-7343-43_Hand
CPchip1_J1, CPchip1_J2: BNC; TE_227161-1
CPchip1_U1, CPchip1_U2, CPchip1_U3, CPchip1_U4: Y1247AstimulusGenerator; ERF8-030-05.0-L-DV-L-TR
CPchip1_U5: CPchip1_CHIP1; 280-5205-01
CPchip1_U6, CPchip1_U10A1: 3pinSwitchCustom; SW_MS12ANW03
CPchip1_U9, CPchip1_U10: E5403A_retention

Connections:
B_inData_bi0: CPchip1_U2.21 (Channel14), CPchip1_U5.65 (B_inData_bi0), CPchip1_U9.29 (B26)
B_inData_bi1: CPchip1_U2.24 (Channel15), CPchip1_U5.64 (B_inData_bi1), CPchip1_U9.28 (B27)
B_inData_bi2: CPchip1_U3.57 (Channel00), CPchip1_U5.63 (B_inData_bi2), CPchip1_U10.1 (A1)
B_inData_bi3: CPchip1_U3.56 (Channel01), CPchip1_U5.62 (B_inData_bi3), CPchip1_U10.2 (A2)
B_inData_bi4: CPchip1_U3.53 (Channel02), CPchip1_U5.59 (B_inData_bi4), CPchip1_U10.53 (B2)
B_inData_bi5: CPchip1_U3.60 (Channel03), CPchip1_U5.58 (B_inData_bi5), CPchip1_U10.52 (B3)
B_inData_bi6: CPchip1_U3.45 (Channel04), CPchip1_U5.57 (B_inData_bi6), CPchip1_U10.4 (A4)
B_inData_bi7: CPchip1_U3.48 (Channel05), CPchip1_U5.56 (B_inData_bi7), CPchip1_U10.5 (A5)
B_inData_bi8: CPchip1_U3.49 (Channel06), CPchip1_U5.55 (B_inData_bi8), CPchip1_U10.50 (B5)
B_inData_bi9: CPchip1_U3.52 (Channel07), CPchip1_U5.54 (B_inData_bi9), CPchip1_U10.49 (B6)
B_inData_bi10: CPchip1_U3.29 (Channel08), CPchip1_U5.53 (B_inData_bi10), CPchip1_U10.47 (B8)
B_inData_bi11: CPchip1_U3.32 (Channel09), CPchip1_U5.48 (B_inData_bi11), CPchip1_U10.46 (B9)
B_outData_bi0: CPchip1_U3.33 (Channel10), CPchip1_U5.47 (B_outData_bi0), CPchip1_U10.10 (A10)
B_outData_bi1: CPchip1_U3.36 (Channel11), CPchip1_U5.46 (B_outData_bi1), CPchip1_U10.11 (A11)
B_outData_bi2: CPchip1_U3.25 (Channel12), CPchip1_U5.45 (B_outData_bi2), CPchip1_U10.44 (B11)
B_outData_bi3: CPchip1_U3.28 (Channel13), CPchip1_U5.44 (B_outData_bi3), CPchip1_U10.43 (B12)
B_outData_bi4: CPchip1_U3.21 (Channel14), CPchip1_U5.43 (B_outData_bi4), CPchip1_U10.13 (A13)
B_outData_bi5: CPchip1_U3.24 (Channel15), CPchip1_U5.42 (B_outData_bi5), CPchip1_U10.14 (A14)
B_outData_bi6: CPchip1_U4.57 (Channel00), CPchip1_U5.39 (B_outData_bi6), CPchip1_U10.41 (B14)
B_outData_bi7: CPchip1_U4.56 (Channel01), CPchip1_U5.38 (B_outData_bi7), CPchip1_U10.40 (B15)
I_DIN: CPchip1_U1.53 (Channel02), CPchip1_U5.5 (I_DIN), CPchip1_U9.53 (B2)
I_FCLK: CPchip1_U1.45 (Channel04), CPchip1_U5.7 (I_FCLK), CPchip1_U9.4 (A4)
I_PGM: CPchip1_U1.60 (Channel03), CPchip1_U5.6 (I_PGM), CPchip1_U9.52 (B3)
I_SCLK: CPchip1_U1.28 (Channel13), CPchip1_U5.32 (I_SCLK), CPchip1_U9.43 (B12)
I_SEL0: CPchip1_U1.32 (Channel09), CPchip1_U5.16 (I_SEL0), CPchip1_U9.46 (B9)
I_SEL1: CPchip1_U1.29 (Channel08), CPchip1_U5.15 (I_SEL1), CPchip1_U9.47 (B8)
I_SEL2: CPchip1_U1.52 (Channel07), CPchip1_U5.14 (I_SEL2), CPchip1_U9.49 (B6)
I_SEL3: CPchip1_U1.49 (Channel06), CPchip1_U5.13 (I_SEL3), CPchip1_U9.50 (B5)
I_SEL4: CPchip1_U1.48 (Channel05), CPchip1_U5.12 (I_SEL4), CPchip1_U9.5 (A5)
I_SI: CPchip1_U1.21 (Channel14), CPchip1_U5.33 (I_SI), CPchip1_U9.13 (A13)
I_address0: CPchip1_U4.53 (Channel02), CPchip1_U5.79 (I_address0), CPchip1_U10.16 (A16)
I_address1: CPchip1_U4.60 (Channel03), CPchip1_U5.78 (I_address1), CPchip1_U10.17 (A17)
I_address2: CPchip1_U4.45 (Channel04), CPchip1_U5.77 (I_address2), CPchip1_U10.38 (B17)
I_address3: CPchip1_U4.48 (Channel05), CPchip1_U5.76 (I_address3), CPchip1_U10.37 (B18)
I_address4: CPchip1_U4.49 (Channel06), CPchip1_U5.75 (I_address4), CPchip1_U10.19 (A19)
I_address5: CPchip1_U4.52 (Channel07), CPchip1_U5.74 (I_address5), CPchip1_U10.20 (A20)
I_clk: CPchip1_U2.56 (Channel01), CPchip1_U5.52 (I_clk), CPchip1_U9.7 (A7), CPchip1_U9.34 (B21), CPchip1_U9.40 (B15), CPchip1_U10.7 (A7), CPchip1_U10.34 (B21)
I_enable: CPchip1_U1.33 (Channel10), CPchip1_U5.17 (I_enable), CPchip1_U9.10 (A10)
I_inData0: CPchip1_U2.53 (Channel02), CPchip1_U5.69 (I_inData0), CPchip1_U9.16 (A16)
I_inData1: CPchip1_U2.45 (Channel04), CPchip1_U5.68 (I_inData1), CPchip1_U9.38 (B17)
I_inData2: CPchip1_U2.48 (Channel05), CPchip1_U5.67 (I_inData2), CPchip1_U9.37 (B18)
I_inData3: CPchip1_U2.49 (Channel06), CPchip1_U5.66 (I_inData3), CPchip1_U9.19 (A19)
I_reset: CPchip1_U2.57 (Channel00), CPchip1_U5.73 (I_reset), CPchip1_U9.41 (B14)
I_scanEn: CPchip1_U1.25 (Channel12), CPchip1_U5.23 (I_scanEn), CPchip1_U9.44 (B11)
I_testmode: CPchip1_U1.36 (Channel11), CPchip1_U5.22 (I_testmode), CPchip1_U9.11 (A11)
unnamed: CPchip1_J1.1 (In), CPchip1_U6.1
unnamed: CPchip1_J2.1 (In), CPchip1_U10A1.1
O_DOUT: CPchip1_U1.56 (Channel01), CPchip1_U5.4 (O_DOUT), CPchip1_U9.2 (A2)
O_SO: CPchip1_U1.24 (Channel15), CPchip1_U5.28 (O_SO), CPchip1_U9.14 (A14)
O_outData0: CPchip1_U2.60 (Channel03), CPchip1_U5.24 (O_outData0), CPchip1_U9.17 (A17)
O_outData1: CPchip1_U2.52 (Channel07), CPchip1_U5.25 (O_outData1), CPchip1_U9.20 (A20)
O_outData2: CPchip1_U2.29 (Channel08), CPchip1_U5.26 (O_outData2), CPchip1_U9.22 (A22)
O_outData3: CPchip1_U2.32 (Channel09), CPchip1_U5.27 (O_outData3), CPchip1_U9.23 (A23)
O_outData4: CPchip1_U2.33 (Channel10), CPchip1_U5.34 (O_outData4), CPchip1_U9.32 (B23)
O_outData5: CPchip1_U2.36 (Channel11), CPchip1_U5.35 (O_outData5), CPchip1_U9.31 (B24)
O_outData6: CPchip1_U2.25 (Channel12), CPchip1_U5.36 (O_outData6), CPchip1_U9.25 (A25)
O_outData7: CPchip1_U2.28 (Channel13), CPchip1_U5.37 (O_outData7), CPchip1_U9.26 (A26)
VDDQ: CPchip1_U1.57 (Channel00), CPchip1_U5.2 (VDDQ), CPchip1_U5.10 (VDDQ), CPchip1_U5.19 (VDDQ), CPchip1_U9.1 (A1)
VDD_IO: CPchip1_C1.1, CPchip1_C2.1, CPchip1_C3.1, CPchip1_C4.1, CPchip1_C9.1, CPchip1_C10.1, CPchip1_C11.1, CPchip1_C12.1, CPchip1_U5.11 (VDD_IO), CPchip1_U5.30 (VDD_IO), CPchip1_U5.50 (VDD_IO), CPchip1_U5.71 (VDD_IO), CPchip1_U6.2
VDD_core: CPchip1_C5.1, CPchip1_C6.1, CPchip1_C7.1, CPchip1_C8.1, CPchip1_C13.1, CPchip1_C14.1, CPchip1_C15.1, CPchip1_C16.1, CPchip1_U5.8 (VDD_core), CPchip1_U5.31 (VDD_core), CPchip1_U5.51 (VDD_core), CPchip1_U5.70 (VDD_core), CPchip1_U10A1.2
VSSQ: CPchip1_C1.2, CPchip1_C2.2, CPchip1_C3.2, CPchip1_C4.2, CPchip1_C5.2, CPchip1_C6.2, CPchip1_C7.2, CPchip1_C8.2, CPchip1_C9.2, CPchip1_C10.2, CPchip1_C11.2, CPchip1_C12.2, CPchip1_C13.2, CPchip1_C14.2, CPchip1_C15.2, CPchip1_C16.2, CPchip1_J1.2 (Ext), CPchip1_J2.2 (Ext), CPchip1_U1.23 (GND), CPchip1_U1.26 (GND), CPchip1_U1.27 (GND), CPchip1_U1.30 (GND), CPchip1_U1.31 (GND), CPchip1_U1.34 (GND), CPchip1_U1.35 (GND), CPchip1_U1.38 (GND), CPchip1_U1.39 (GND), CPchip1_U1.42 (GND), CPchip1_U1.43 (GND), CPchip1_U1.46 (GND), CPchip1_U1.47 (GND), CPchip1_U1.50 (GND), CPchip1_U1.51 (GND), CPchip1_U1.54 (GND), CPchip1_U1.55 (GND), CPchip1_U1.58 (GND), CPchip1_U1.59 (GND), CPchip1_U2.23 (GND), CPchip1_U2.26 (GND), CPchip1_U2.27 (GND), CPchip1_U2.30 (GND), CPchip1_U2.31 (GND), CPchip1_U2.34 (GND), CPchip1_U2.35 (GND), CPchip1_U2.38 (GND), CPchip1_U2.39 (GND), CPchip1_U2.42 (GND), CPchip1_U2.43 (GND), CPchip1_U2.46 (GND), CPchip1_U2.47 (GND), CPchip1_U2.50 (GND), CPchip1_U2.51 (GND), CPchip1_U2.54 (GND), CPchip1_U2.55 (GND), CPchip1_U2.58 (GND), CPchip1_U2.59 (GND), CPchip1_U3.23 (GND), CPchip1_U3.26 (GND), CPchip1_U3.27 (GND), CPchip1_U3.30 (GND), CPchip1_U3.31 (GND), CPchip1_U3.34 (GND), CPchip1_U3.35 (GND), CPchip1_U3.38 (GND), CPchip1_U3.39 (GND), CPchip1_U3.42 (GND), CPchip1_U3.43 (GND), CPchip1_U3.46 (GND), CPchip1_U3.47 (GND), CPchip1_U3.50 (GND), CPchip1_U3.51 (GND), CPchip1_U3.54 (GND), CPchip1_U3.55 (GND), CPchip1_U3.58 (GND), CPchip1_U3.59 (GND), CPchip1_U4.23 (GND), CPchip1_U4.26 (GND), CPchip1_U4.27 (GND), CPchip1_U4.30 (GND), CPchip1_U4.31 (GND)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

Notes on the sheet:
Coupling Capacitors
Universal Ground
BNC Connector
Stimulus Generator Connectors (Y1247A)
Chip 1
Logic Analyzer Connectors (E5406A) - Contactless connector

Board: 4 copper layers, 113.0 x 113.8 mm, 27 parts (16 on the bottom side), 61 nets.

## KiCad design ChipTwo/ChipTwo.kicad_pcb

Board: 4 copper layers, 111.0 x 105.0 mm, 27 parts (0 on the bottom side), 65 nets.

Parts:
CPchip2_C1, CPchip2_C2, CPchip2_C5, CPchip2_C6, CPchip2_C9, CPchip2_C10, CPchip2_C13, CPchip2_C14: 10uF; C_1206_HandSoldering
CPchip2_C3, CPchip2_C4, CPchip2_C7, CPchip2_C8, CPchip2_C11, CPchip2_C12, CPchip2_C15, CPchip2_C16: 100uF; CP_Tantalum_Case-X_EIA-7343-43_Hand
CPchip2_J1, CPchip2_J2: Conn_Coaxial; TE_227161-1
CPchip2_J3, CPchip2_J4: 5767007-8; TE_5767007-8
CPchip2_U1, CPchip2_U2, CPchip2_U3, CPchip2_U4: Y1247AstimulusGenerator; ERF8-030-05.0-L-DV-L-TR
CPchip2_U5: CPchip2_CHIP2; 280-5205-01
CPchip2_U6, CPchip2_U11: 3pinSwitchCustom; SW_MS12ANW03

Connections:
unnamed: CPchip2_J1.1, CPchip2_U6.1
unnamed: CPchip2_J2.1, CPchip2_U11.1
SCLK: CPchip2_J3.33, CPchip2_U1.53, CPchip2_U5.52
SI: CPchip2_J3.31, CPchip2_U1.60, CPchip2_U5.53
SO: CPchip2_J3.29, CPchip2_U1.45, CPchip2_U5.54
VDD_IO: CPchip2_C1.1, CPchip2_C2.1, CPchip2_C3.1, CPchip2_C4.1, CPchip2_C9.1, CPchip2_C10.1, CPchip2_C11.1, CPchip2_C12.1, CPchip2_U5.10, CPchip2_U5.30, CPchip2_U5.50, CPchip2_U5.70, CPchip2_U11.2
VDD_core: CPchip2_C5.1, CPchip2_C6.1, CPchip2_C7.1, CPchip2_C8.1, CPchip2_C13.1, CPchip2_C14.1, CPchip2_C15.1, CPchip2_C16.1, CPchip2_U5.9, CPchip2_U5.29, CPchip2_U5.49, CPchip2_U5.69, CPchip2_U6.2
VSS_IO: CPchip2_C1.2, CPchip2_C2.2, CPchip2_C3.2, CPchip2_C4.2, CPchip2_C5.2, CPchip2_C6.2, CPchip2_C7.2, CPchip2_C8.2, CPchip2_C9.2, CPchip2_C10.2, CPchip2_C11.2, CPchip2_C12.2, CPchip2_C13.2, CPchip2_C14.2, CPchip2_C15.2, CPchip2_C16.2, CPchip2_J1.2, CPchip2_J2.2, CPchip2_J3.S1, CPchip2_J3.S2, CPchip2_J3.S3, CPchip2_J3.S4, CPchip2_J3.S5, CPchip2_J4.S1, CPchip2_J4.S2, CPchip2_J4.S3, CPchip2_J4.S4, CPchip2_J4.S5, CPchip2_U1.23, CPchip2_U1.26, CPchip2_U1.27, CPchip2_U1.30, CPchip2_U1.31, CPchip2_U1.34, CPchip2_U1.35, CPchip2_U1.38, CPchip2_U1.39, CPchip2_U1.42, CPchip2_U1.43, CPchip2_U1.46, CPchip2_U1.47, CPchip2_U1.50, CPchip2_U1.51, CPchip2_U1.54, CPchip2_U1.55, CPchip2_U1.58, CPchip2_U1.59, CPchip2_U2.23, CPchip2_U2.26, CPchip2_U2.27, CPchip2_U2.30, CPchip2_U2.31, CPchip2_U2.34, CPchip2_U2.35, CPchip2_U2.38, CPchip2_U2.39, CPchip2_U2.42, CPchip2_U2.43, CPchip2_U2.46, CPchip2_U2.47, CPchip2_U2.50, CPchip2_U2.51, CPchip2_U2.54, CPchip2_U2.55, CPchip2_U2.58, CPchip2_U2.59, CPchip2_U3.23, CPchip2_U3.26, CPchip2_U3.27, CPchip2_U3.30, CPchip2_U3.31, CPchip2_U3.34, CPchip2_U3.35, CPchip2_U3.38, CPchip2_U3.39, CPchip2_U3.42, CPchip2_U3.43, CPchip2_U3.46, CPchip2_U3.47, CPchip2_U3.50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
clk: CPchip2_J3.5, CPchip2_J3.6, CPchip2_J3.25, CPchip2_J4.5, CPchip2_J4.6, CPchip2_U1.49, CPchip2_U5.12
i[0]: CPchip2_J3.23, CPchip2_U1.52, CPchip2_U5.7
io[0]: CPchip2_J3.19, CPchip2_U1.32, CPchip2_U5.35
io[1]: CPchip2_J3.17, CPchip2_U1.33, CPchip2_U5.36
io[2]: CPchip2_J3.15, CPchip2_U1.36, CPchip2_U5.37
io[3]: CPchip2_J3.13, CPchip2_U1.25, CPchip2_U5.38
io[4]: CPchip2_J3.11, CPchip2_U1.28, CPchip2_U5.39
io[5]: CPchip2_J3.9, CPchip2_U1.21, CPchip2_U5.42
io[6]: CPchip2_J3.7, CPchip2_U1.24, CPchip2_U5.43
io[7]: CPchip2_J3.38, CPchip2_U2.57, CPchip2_U5.44
io[8]: CPchip2_J3.36, CPchip2_U2.56, CPchip2_U5.45
io[9]: CPchip2_J3.34, CPchip2_U2.53, CPchip2_U5.46
io[10]: CPchip2_J3.32, CPchip2_U2.60, CPchip2_U5.47
io[11]: CPchip2_J3.30, CPchip2_U2.45, CPchip2_U5.48
io[12]: CPchip2_J3.28, CPchip2_U2.48, CPchip2_U5.55
io[13]: CPchip2_J3.26, CPchip2_U2.49, CPchip2_U5.56
io[14]: CPchip2_J3.24, CPchip2_U2.52, CPchip2_U5.57
io[15]: CPchip2_J3.22, CPchip2_U2.29, CPchip2_U5.58
io[16]: CPchip2_J3.20, CPchip2_U2.32, CPchip2_U5.59
io[17]: CPchip2_J3.18, CPchip2_U2.33, CPchip2_U5.62
io[18]: CPchip2_J3.16, CPchip2_U2.36, CPchip2_U5.63
io[19]: CPchip2_J3.14, CPchip2_U2.25, CPchip2_U5.64
io[20]: CPchip2_J3.12, CPchip2_U2.28, CPchip2_U5.65
io[21]: CPchip2_J3.10, CPchip2_U2.21, CPchip2_U5.66
io[22]: CPchip2_J3.8, CPchip2_U2.24, CPchip2_U5.67
io[23]: CPchip2_J4.37, CPchip2_U3.57, CPchip2_U5.68
io[24]: CPchip2_J4.35, CPchip2_U3.56, CPchip2_U5.72
io[25]: CPchip2_J4.33, CPchip2_U3.53, CPchip2_U5.73
io[26]: CPchip2_J4.31, CPchip2_U3.60, CPchip2_U5.74
io[27]: CPchip2_J4.29, CPchip2_U3.45, CPchip2_U5.75
io[28]: CPchip2_J4.27, CPchip2_U3.48, CPchip2_U5.76
io[29]: CPchip2_J4.25, CPchip2_U3.49, CPchip2_U5.77
io[30]: CPchip2_J4.23, CPchip2_U3.52, CPchip2_U5.78
io[31]: CPchip2_J4.21, CPchip2_U3.29, CPchip2_U5.79
o[0]: CPchip2_J3.21, CPchip2_U1.29, CPchip2_U5.8
o[1]: CPchip2_J4.19, CPchip2_U3.32, CPchip2_U5.13
o[2]: CPchip2_J4.17, CPchip2_U3.33, CPchip2_U5.14
o[3]: CPchip2_J4.15, CPchip2_U3.36, CPchip2_U5.15
o[4]: CPchip2_J4.13, CPchip2_U3.25, CPchip2_U5.16
o[5]: CPchip2_J4.11, CPchip2_U3.28, CPchip2_U5.17
o[6]: CPchip2_J4.9, CPchip2_U3.21, CPchip2_U5.18
o[7]: CPchip2_J4.7, CPchip2_U3.24, CPchip2_U5.19
o[8]: CPchip2_J4.38, CPchip2_U4.57, CPchip2_U5.22
o[9]: CPchip2_J4.36, CPchip2_U4.56, CPchip2_U5.23
o[10]: CPchip2_J4.34, CPchip2_U4.53, CPchip2_U5.24
o[11]: CPchip2_J4.32, CPchip2_U4.60, CPchip2_U5.25
o[12]: CPchip2_J4.30, CPchip2_U4.45, CPchip2_U5.26
o[13]: CPchip2_J4.28, CPchip2_U4.48, CPchip2_U5.27
o[14]: CPchip2_J4.26, CPchip2_U4.49, CPchip2_U5.28
o[15]: CPchip2_J4.24, CPchip2_U4.52, CPchip2_U5.32
o[16]: CPchip2_J4.22, CPchip2_U4.29, CPchip2_U5.33
o[17]: CPchip2_J4.20, CPchip2_U4.32, CPchip2_U5.34
reset: CPchip2_J3.27, CPchip2_U1.48, CPchip2_U5.4
scanEn: CPchip2_J3.35, CPchip2_U1.56, CPchip2_U5.6
select[0]: CPchip2_J4.18, CPchip2_U4.33, CPchip2_U5.2
select[1]: CPchip2_J4.16, CPchip2_U4.36, CPchip2_U5.3
testmode: CPchip2_J3.37, CPchip2_U1.57, CPchip2_U5.5

Notices in the files:
parts and their libraries:
Copyright 2016 Accelerated Designs. All rights reserved.
