# Repository chyavanphadke/University-Research-PCB-Design (continued)

## KiCad design chipOne/chipOne_Backup.kicad_pcb

Parts:
C1, C2, C5, C6, C9, C10, C13, C14: 10uF; C_1206_HandSoldering
C3, C4, C7, C8, C11, C12, C15, C16: 100uF; CP_Tantalum_Case-X_EIA-7343-43_Hand
J1, J2: BNC; TE_227161-1
J3, J4: 5767007-8; TE_5767007-8
U1, U2, U3, U4: Y1247AstimulusGenerator; ERF8-030-05.0-L-DV-L-TR
U5: CHIP1; 280-5205-01
U6, U10A1: 3pinSwitchCustom; SW_MS12ANW03

Connections:
B_inData_bi0: U2.21 (Channel14), U5.65 (B_inData_bi0)
B_inData_bi1: U2.24 (Channel15), U5.64 (B_inData_bi1)
B_inData_bi2: U3.57 (Channel00), U5.63 (B_inData_bi2)
B_inData_bi3: U3.56 (Channel01), U5.62 (B_inData_bi3)
B_inData_bi4: U3.53 (Channel02), U5.59 (B_inData_bi4)
B_inData_bi5: U3.60 (Channel03), U5.58 (B_inData_bi5)
B_inData_bi6: U3.45 (Channel04), U5.57 (B_inData_bi6)
B_inData_bi7: U3.48 (Channel05), U5.56 (B_inData_bi7)
B_inData_bi8: U3.49 (Channel06), U5.55 (B_inData_bi8)
B_inData_bi9: U3.52 (Channel07), U5.54 (B_inData_bi9)
B_inData_bi10: U3.29 (Channel08), U5.53 (B_inData_bi10)
B_inData_bi11: U3.32 (Channel09), U5.48 (B_inData_bi11)
B_outData_bi0: U3.33 (Channel10), U5.47 (B_outData_bi0)
B_outData_bi1: U3.36 (Channel11), U5.46 (B_outData_bi1)
B_outData_bi2: U3.25 (Channel12), U5.45 (B_outData_bi2)
B_outData_bi3: U3.28 (Channel13), U5.44 (B_outData_bi3)
B_outData_bi4: U3.21 (Channel14), U5.43 (B_outData_bi4)
B_outData_bi5: U3.24 (Channel15), U5.42 (B_outData_bi5)
B_outData_bi6: U4.57 (Channel00), U5.39 (B_outData_bi6)
B_outData_bi7: U4.56 (Channel01), U5.38 (B_outData_bi7)
I_DIN: U1.53 (Channel02), U5.5 (I_DIN)
I_FCLK: U1.45 (Channel04), U5.7 (I_FCLK)
I_PGM: U1.60 (Channel03), U5.6 (I_PGM)
I_SCLK: U1.28 (Channel13), U5.32 (I_SCLK)
I_SEL0: U1.32 (Channel09), U5.16 (I_SEL0)
I_SEL1: U1.29 (Channel08), U5.15 (I_SEL1)
I_SEL2: U1.52 (Channel07), U5.14 (I_SEL2)
I_SEL3: U1.49 (Channel06), U5.13 (I_SEL3)
I_SEL4: U1.48 (Channel05), U5.12 (I_SEL4)
I_SI: U1.21 (Channel14), U5.33 (I_SI)
I_address0: U4.53 (Channel02), U5.79 (I_address0)
I_address1: U4.60 (Channel03), U5.78 (I_address1)
I_address2: U4.45 (Channel04), U5.77 (I_address2)
I_address3: U4.48 (Channel05), U5.76 (I_address3)
I_address4: U4.49 (Channel06), U5.75 (I_address4)
I_address5: U4.52 (Channel07), U5.74 (I_address5)
I_clk: U2.56 (Channel01), U5.52 (I_clk)
I_enable: U1.33 (Channel10), U5.17 (I_enable)
I_inData0: U2.53 (Channel02), U5.69 (I_inData0)
I_inData1: U2.45 (Channel04), U5.68 (I_inData1)
I_inData2: U2.48 (Channel05), U5.67 (I_inData2)
I_inData3: U2.49 (Channel06), U5.66 (I_inData3)
I_reset: U2.57 (Channel00), U5.73 (I_reset)
I_scanEn: U1.25 (Channel12), U5.23 (I_scanEn)
I_testmode: U1.36 (Channel11), U5.22 (I_testmode)
unnamed: J1.1 (In), U6.1
unnamed: J2.1 (In), U10A1.1
O_DOUT: U1.56 (Channel01), U5.4 (O_DOUT)
O_SO: U1.24 (Channel15), U5.28 (O_SO)
O_outData0: U2.60 (Channel03), U5.24 (O_outData0)
O_outData1: U2.52 (Channel07), U5.25 (O_outData1)
O_outData2: U2.29 (Channel08), U5.26 (O_outData2)
O_outData3: U2.32 (Channel09), U5.27 (O_outData3)
O_outData4: U2.33 (Channel10), U5.34 (O_outData4)
O_outData5: U2.36 (Channel11), U5.35 (O_outData5)
O_outData6: U2.25 (Channel12), U5.36 (O_outData6)
O_outData7: U2.28 (Channel13), U5.37 (O_outData7)
VDDQ: U1.57 (Channel00), U5.2 (VDDQ), U5.10 (VDDQ), U5.19 (VDDQ)
VDD_IO: C1.1, C2.1, C3.1, C4.1, C9.1, C10.1, C11.1, C12.1, U5.11 (VDD_IO), U5.30 (VDD_IO), U5.50 (VDD_IO), U5.71 (VDD_IO), U6.2
VDD_core: C5.1, C6.1, C7.1, C8.1, C13.1, C14.1, C15.1, C16.1, U5.8 (VDD_core), U5.31 (VDD_core), U5.51 (VDD_core), U5.70 (VDD_core), U10A1.2
VSSQ: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, J1.2 (Ext), J2.2 (Ext), U1.23 (GND), U1.26 (GND), U1.27 (GND), U1.30 (GND), U1.31 (GND), U1.34 (GND), U1.35 (GND), U1.38 (GND), U1.39 (GND), U1.42 (GND), U1.43 (GND), U1.46 (GND), U1.47 (GND), U1.50 (GND), U1.51 (GND), U1.54 (GND), U1.55 (GND), U1.58 (GND), U1.59 (GND), U2.23 (GND), U2.26 (GND), U2.27 (GND), U2.30 (GND), U2.31 (GND), U2.34 (GND), U2.35 (GND), U2.38 (GND), U2.39 (GND), U2.42 (GND), U2.43 (GND), U2.46 (GND), U2.47 (GND), U2.50 (GND), U2.51 (GND), U2.54 (GND), U2.55 (GND), U2.58 (GND), U2.59 (GND), U3.23 (GND), U3.26 (GND), U3.27 (GND), U3.30 (GND), U3.31 (GND), U3.34 (GND), U3.35 (GND), U3.38 (GND), U3.39 (GND), U3.42 (GND), U3.43 (GND), U3.46 (GND), U3.47 (GND), U3.50 (GND), U3.51 (GND), U3.54 (GND), U3.55 (GND), U3.58 (GND), U3.59 (GND), U4.23 (GND), U4.26 (GND), U4.27 (GND), U4.30 (GND), U4.31 (GND)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

Notes on the sheet:
Coupling Capacitors
Universal Ground
BNC Connector
Stimulus Generator Connectors (Y1247A)
Chip 1
Logic Analyzer Connectors (U4205)

Board: 2 copper layers, 116.8 x 106.7 mm, 25 parts (16 on the bottom side), 61 nets.

## Commit log

2020-06-07 project initilised
2020-06-07 Chip 1 added and connections made
2020-06-07 Chip pcb initial stahe and schematic completed, Generator to DUT socket and connections are made
2020-06-07 Chip One first netlist generated
2020-06-08 Stage one of Chip 1 is completed
2020-06-09 Layout for PCB one made : stage 1
2020-06-09 Layout Done and routings made
2020-06-09 PCB Layout Done and Dusted !
2020-06-11 Chip Two design and schematic completed
2020-06-11 Code cleanup
2020-06-12 Almost completed with both the chip work
2020-06-12 Code clean up
2020-06-12 Combined both the PCB's
2020-06-12 Combined both the boards
2020-06-15 Switch changed in both the layout
2020-06-18 Old version of the project also added and uploadded
2020-06-18 Report of the CHIP added
2020-06-19 Testing for all connections in Chip One is Completed
2020-06-19 Checking for chip two completed, Combined PCB updated
2020-06-19 Both Chips final modification done
2020-06-20 Combined files modified
2020-06-20 Mounting holes added to all boards
2020-06-20 Bill Of Meterials created for all 3 PCB
2020-07-20 A lot of Changes made and the design has been updated
2020-07-20 Retaining the old designs as well
2020-08-08 Changes finilised
